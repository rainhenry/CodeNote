# Keil uVision project KB926_TEST.uvproj, settings and files
target KB926_TEST (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: KB926_TEST +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\BSP;.\CSP;.\USER
  group CSP
    ./CSP/: KB926.c InterruptionService.c startup.a51
  group USER
    ./USER/: main.c User.h
